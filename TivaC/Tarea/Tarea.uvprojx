# Keil uVision project Tarea.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C129CNCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tarea
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../Puertos/: startup.s
    ./: Tarea3_GenerEcheverria.s
software components: CMSIS:CORE 5.4.0
